# Keil uVision project Lab5_I2C.uvprojx, settings and files
target Lab5_I2C (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Lab5_I2C
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f0xx_hal_msp.c stm32f0xx_it.c main.c ins_types.c MPU9250.c
    ../../../../MadgwickFilter/MadgwickAHRS/: MadgwickAHRS.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
software components: CMSIS:CORE 4.1.0
